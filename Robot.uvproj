# Keil uVision project Robot.uvproj, settings and files
target Robot (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Robot
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR MOTOR_BOARD
  c misc: --c99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c OS.c ADC.c Robot.c can.c can0.c interrupt.c PWM.c usonic.c WTimer0A.c WTimer0B.c WTimer5A.c ST7735.c SysTick.c ThreadSwitch.s Drive.c
